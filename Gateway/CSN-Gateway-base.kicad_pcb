# Repository blackPantherOS/calaos_sensor_network

File README.md:

# calaos_sensor_network
Calaos Sensort Network, set of hardware designs for Calaos

## KiCad design Gateway/CSN-Gateway-base.kicad_pcb

Parts:
C1, C2, C8, C11, C12: 0.1uF; C_0805_HandSoldering
C3, C4: 22pF; C_0805_HandSoldering
C5, C6, C7, C9, C10, C13, C17, C20: 10uF; CP_Tantalum_Case-R_EIA-2012-12_Hand
C14, C16, C18: 100nF; C_0805_HandSoldering
D2: TL431; SOT-23
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
P1: CONN_02X06; IDC_Header_Straight_12pins
P2: CONN4; TerminalBlock_Multicomp-5-08-6pol
P3: CONN_ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
P5: CONN6; TerminalBlock_Multicomp-5-08-6pol
Q1: 2N2222; SOT-23
R1, R3, R4, R6, R7, R9, R10, R11, R12, R13, R29, R30: 10K; R_0805_HandSoldering
R2, R5, R8, R28: 33; R_0805_HandSoldering
R14: 10KR; R_0805_HandSoldering
R17, R18: 20K; R_0805_HandSoldering
R19: 120; R_0805_HandSoldering
R24: 1.5K; R_0805_HandSoldering
R25, R26: 27.4K; R_0805_HandSoldering
RADIO1: CONN_NRF24L01; NRF24L01
U1: MAX485CSA; SO-8
U2: AMS1117-3.3V; SOT-223
U3: ATSHA204A; SOT-23_Handsoldering
Y1: Crystal; Crystal_SMD_5032-2pin_5.0x3.2mm

Connections:
A0: IC1.19 (ADC6), P5.2, R2.1
A1: IC1.22 (ADC7), P5.4, R8.1
A2: IC1.23 ((PCINT8/ADC0)PC0), P5.6, R5.1
A3: IC1.24 ((PCINT9/ADC1)PC1), P2.5, R28.1
BTN1: IC1.2 ((PCINT20/XCK/T0)PD4), P1.8
BTN2: IC1.10 ((PCINT22/OC0A/AIN0)PD6), P1.10
CE: IC1.13 ((PCINT1/OC1A)PB1), RADIO1.3
CSN: IC1.14 ((PCINT2/OC1B/~SS~)PB2), RADIO1.4
CT1-A0: C20.1, P2.6, R28.2, R29.1, R30.1
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C20.2, D2.3 (A), IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P1.3, P2.1, P3.6, R4.2, R7.2, R10.2, R18.2, R26.2, R30.2, RADIO1.1, U1.5 (GND), U2.1 (GND), U3.3 (GND)
IRQ: IC1.32 ((PCINT18/INT0)PD2), RADIO1.8
MISO: IC1.16 ((PCINT4/MISO)PB4), P3.1, RADIO1.7
MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P3.4, RADIO1.6
unnamed: C1.1, IC1.20 (AREF)
unnamed: C3.1, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: C4.1, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
unnamed: C5.1, P5.1, R2.2, R3.1, R4.1
unnamed: C6.1, P5.5, R5.2, R6.1, R7.1
unnamed: C7.1, P5.3, R8.2, R9.1, R10.1
unnamed: C9.1, C11.1, RADIO1.2, U2.2 (VO)
unnamed: C16.1, D2.1 (Ref), R25.2, R26.1
unnamed: D2.2 (K), Q1.1 (B), R24.2
unnamed: P2.2, Q1.3 (C), R24.1
RGB1: IC1.12 ((PCINT0/CLKO/ICP1)PB0), P1.12
RGB2: IC1.11 ((PCINT23/AIN1)PD7), P1.11
RGB3: IC1.9 ((PCINT21/OC0B/T1)PD5), P1.9
RRST: C2.1, IC1.29 ((PCINT14/~RESET~)PC6), P3.5, R1.2
RS485-A: P2.4, R17.2, R19.2, U1.6 (A)
RS485-B: P2.3, R18.1, R19.1, U1.7 (B)
RS485_EN: IC1.26 ((PCINT11/ADC3)PC3), R12.2, R13.2, U1.2 (~RE~), U1.3 (DE)
RS485_RX: IC1.1 ((PCINT19/OC2B/INT1)PD3), R11.2, U1.4 (DI)
RS485_TX: IC1.25 ((PCINT10/ADC2)PC2), R14.2, U1.1 (RO)
RST: C2.2, P1.6
RXI: IC1.30 ((PCINT16/RXD)PD0), P1.2
SCK: IC1.17 ((PCINT5/SCK)PB5), P3.3, RADIO1.5
SCL: IC1.28 ((PCINT13/SCL/ADC5)PC5), P1.5
SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), P1.7, U3.1 (SDA)
TXO: IC1.31 ((PCINT17/TXD)PD1), P1.4
VCC: C8.2, C10.1, C12.1, C13.1, C14.1, C17.1, C18.1, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), P1.1, P3.2, Q1.2 (E), R1.1, R3.2, R6.2, R9.2, R11.1, R12.1, R13.1, R14.1, R17.1, R25.1, R29.2, U1.8 (VCC), U2.3 (VI), U3.2 (VCC)

Notes on the sheet:
Burden Res.
R24 = (Vin - 5.6V) / I I = 10mA for 24V Imin for 5V = 5mA
GND
+5V/+24V
RS485-B
RS485-A

Board: 4 copper layers, 32.0 x 85.5 mm, 53 parts (0 on the bottom side), 39 nets.

## KiCad design Gateway/CSN-Gateway-screen.kicad_pcb

Parts:
C1, C15: 100nF; C_0805_HandSoldering
C19: 10uF; CP_Tantalum_Case-R_EIA-2012-12_Hand
D1: LED_RABG; LedRGB_MULTICOMP_703-1028
IC2: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm
P1: USB_MINI; MolexUSB_Mini-B_67503-1020
P2: CONN_01X12; IDC_Header_Straight_12pins
P4: CONN_OLED_SCREEN; Socket_Strip_Straight_1x04
R15, R27: 10K; R_0805_HandSoldering
R16, R22, R23: 1K; R_0805_HandSoldering
SW1, SW2: SW_PUSH; SW_PUSH_6mm

Connections:
BTN1: P2.8, R15.2, SW1.2
BTN2: P2.10, R27.2, SW2.2
GND: C1.1, C15.2, C19.2, IC2.7 (GND@7), IC2.18 (GND@18), IC2.21 (GND@21), IC2.25 (AGND), IC2.26 (TEST), P1.5 (GND), P1.6 (shield), P2.3, P4.1, R15.1, R27.1
unnamed: C1.2, IC2.17 (3V3OUT)
unnamed: C15.1, C19.1, IC2.4 (VCCIO), IC2.20 (VCC), P1.1 (VCC)
unnamed: D1.1 (RED_CATHODE), R16.2
unnamed: D1.2 (BLUE_CATHODE), R23.2
unnamed: D1.4 (GREEN_CATHODE), R22.2
unnamed: IC2.15 (USBDP), P1.3 (D+)
unnamed: IC2.16 (USBDM), P1.2 (D-)
RGB1: P2.12, R16.1
RGB2: P2.11, R22.1
RGB3: P2.9, R23.1
RST: IC2.2 (!DTR), P2.6
RXI: IC2.5 (RXD), P2.4
SCL: P2.5, P4.3
SDA: P2.7, P4.4
TXO: IC2.1 (TXD), P2.2
VCC: D1.3 (COMMON_ANODE), P2.1, P4.2, SW1.1, SW2.1

Board: 2 copper layers, 32.0 x 58.0 mm, 15 parts (4 on the bottom side), 19 nets.

## KiCad design Temp-Humidity/temp-humidity.kicad_pcb

Parts:
C1, C3, C4: C_Small; C_0805_HandSoldering
C2: 100uF; C_0805_HandSoldering
C5, C6: 12pF; C_0805_HandSoldering
C7: 4u7; C_0805_HandSoldering
D1: LED; LED_0805
IC1: ATMEGA328P-A; TQFP-32_7x7mm_Pitch0.8mm
JP1: Jumper_NO_Small; Pin_Header_Straight_1x02
P1: BATTERY; JST_PH_S2B-PH-K_02x2.00mm_Angled
P2: CONN_02X03; Pin_Header_Straight_2x03
P3: SERIAL/DEBUG; Pin_Header_Straight_1x06
P4: ANTENNA; Measurement_Point_Round-TH_Big
R1, R3: 10k; R_0805_HandSoldering
R2: 160; R_0805_HandSoldering
R4, R5, R6, R7: 4k7; R_0805_HandSoldering
SW1: SW_PUSH_SMALL_H; SW_06_SMD
U1: AT25DF512; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: HDC1080; SC-70-6
U3: ATSHA204A; SOT-23_Handsoldering
U4: NRF24L01; NRF24L01-SMD
U5: RFM69HW; RFM69HW_SMD
Y1: 12MHz; XTAL_3.2x1.5mm

Connections:
+3V3: C1.1, C2.1, C3.1, C7.1, D1.2 (A), IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), JP1.2, P1.2, P2.2, R3.1, R4.1, R5.1, R6.1, R7.1, SW1.1, U1.3 (~WP), U1.7 (~HOLD), U1.8 (Vcc), U2.5 (VDD), U3.2 (VCC), U4.2 (VCC), U5.16 (3.3V)
/BTN1: IC1.23 ((PCINT8/ADC0)PC0), R1.1, SW1.2
/CE: IC1.13 ((PCINT1/OC1A)PB1), U4.3 (CE)
/CSN: IC1.14 ((PCINT2/OC1B/~SS~)PB2), U4.4 (CSN), U5.2 (NSS)
/DTR: IC1.29 ((PCINT14/~RESET~)PC6), P3.1, R3.2
/FLASH_CS: IC1.12 ((PCINT0/CLKO/ICP1)PB0), R4.2, U1.1 (~CS)
/IRQ: IC1.32 ((PCINT18/INT0)PD2), U4.8 (IRQ), U5.10 (DIO0)
/MISO: IC1.16 ((PCINT4/MISO)PB4), P2.1, U1.2 (MISO), U4.7 (MISO), U5.4 (MISO)
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P2.4, U1.5 (MOSI), U4.6 (MOSI), U5.3 (MOSI)
/RESET: P2.5, R7.2
/RX: IC1.30 ((PCINT16/RXD)PD0), P3.3
/SCK: IC1.17 ((PCINT5/SCK)PB5), P2.3, U1.6 (SCK), U4.5 (SCK), U5.5 (SCK)
/SCL: IC1.28 ((PCINT13/SCL/ADC5)PC5), R5.2, U2.6 (SCL)
/SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), R6.2, U2.1 (SDA), U3.1 (SDA)
/TX: IC1.31 ((PCINT17/TXD)PD1), P3.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P1.1, P2.6, P3.5, P3.6, R1.2, U1.4 (GND), U2.2 (GND), U3.3 (GND), U4.1 (GND), U5.6 (GND), U5.8 (GND)
unnamed: C4.1, IC1.20 (AREF)
unnamed: C5.2, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: C6.2, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
unnamed: D1.1 (K), R2.1
unnamed: IC1.2 ((PCINT20/XCK/T0)PD4), R2.2
unnamed: P4.1, U5.7 (ANA)
VDD: JP1.1, P3.4

Board: 2 copper layers, 34.0 x 74.0 mm, 28 parts (0 on the bottom side), 23 nets.

## KiCad design Gateway/Conso.kicad_pcb

Parts:
C1, C2: 0.1uF
C3, C4: 22pF
IC1: ATMEGA328-A; TQFP32
P1: CONN_01X06
P2: CONN_01X02
P3: CONN_02X03
R1: 10K
Y1: Crystal

Connections:
DTR: C2.1, P1.6
GND: C1.2, C3.2, C4.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P1.1, P1.2, P2.1, P3.6
MISO: IC1.16 ((PCINT4/MISO)PB4), P3.1
MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P3.4
unnamed: C1.1, IC1.20 (AREF)
unnamed: C3.1, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: C4.1, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
RST: C2.2, IC1.29 ((PCINT14/~RESET~)PC6), P3.5, R1.2
RXI: IC1.30 ((PCINT16/RXD)PD0), P1.4
SCK: IC1.17 ((PCINT5/SCK)PB5), P3.3
TXO: IC1.31 ((PCINT17/TXD)PD1), P1.5
VCC: IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), P1.3, P2.2, P3.2, R1.1

Board: 2 copper layers, 63.9 x 46.5 mm, 11 parts (0 on the bottom side), 12 nets.

Other parts of the board:
U1: Test; test_empreinte

## Commit log

2016-11-25 Add schematics in PDF format
2016-11-25 Update Debug 3v3 detection
2016-11-25 finish gateway schematics
2016-11-27 More work on gateway
    - Add ftdi ft232rl chip for usb comms
    - Remove debug connector (not used if we have usb)
    - Add capa and resistors to rs485
    - Draw edge cut for both bottom and top pcb at the correct size of the
    case
2016-11-27 Add switch for 3v3 / Serial debug port alimentation and use Timer mode for TPL5110
2016-11-27 Update schematics
2016-11-27 FT232R in Self powered mode + switch button
2016-11-27 Change capa
2016-11-28 update pdf
2016-11-29 Finish gateway power supply
2016-11-29 Fix ft232 self powered schematic
2016-11-29 add some pcb footprint
2016-11-30 change to 0806
2016-11-30 add some components
2016-12-01 add 4th ct sensor input
2016-12-01 Split project into 2 sch + 2 pcb (screen + base)
2016-12-01 add multicomp footprint
2016-12-02 add all missing footprints
2016-12-02 finish screen pcb routing
2016-12-02 begin placement of compo on base pcb
2016-12-04 Finish base pcb routing and adjust all mounting holes
2016-12-04 pin 4 of ams1117 to gnd
2016-12-04 add silkscreen infos on pcb
2016-12-05 add cuts for mouting
2016-12-30 fix wrong footprints
2017-01-01 Fix footprints for power supply components
2017-01-01 More work on hum/temp sensor
2017-01-08 Remove alimentation
2017-01-08 pcb edge cut with this box : http://www.farnell.com/datasheets/682682.pdf
2017-01-08 More work on hum/temp
2017-01-08 work++
2017-01-08 More work on pcb, but bad cutting edges
2017-02-22 new pcb for v1.1 prototype
2017-02-22 add missing logo to screen pcb
2017-02-24 4 layers version of the base pcb
2017-03-22 Fix wrong reset pin for ICSP, fix exchange of rx/tx in ftdi
2017-03-22 add BOM
